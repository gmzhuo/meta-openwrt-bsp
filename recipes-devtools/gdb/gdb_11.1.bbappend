FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += " file://0900-fix-gdb-server-complain-unknow-tag_ctl.patch"